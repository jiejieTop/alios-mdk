# Keil uVision project fire_aliso.uvprojx, settings and files
target fire_aliso (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fire_aliso +hex
  c flags: Optim=2 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\alios\osal\include;..\..\alios\kernel\rhino\core\include;..\..\alios\kernel\rhino\common;..\..\alios\kernel\rhino\debug\include;..\..\alios\armv7m\armcc\m3;..\..\User\usart;..\..\User\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c soc_impl.c soc_init.c k_config.h soc_init.h
    ../../User/Led/: bsp_led.c
    ../../User/usart/: bsp_usart.c
    ../../User/key/: bsp_key.c
  group alios/osal
    ../../alios/osal/aos/: aos_rhino.c
  group alios/core
    ../../alios/kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group alios/common
    ../../alios/kernel/rhino/common/: k_fifo.c k_trace.c
  group alios/debug
    ../../alios/kernel/rhino/debug/: k_backtrace.c k_infoget.c k_overview.c k_panic.c
  group alios/cpu
    ../../alios/armv7m/armcc/m3/: port_s.s port_c.c k_types.h port.h
  group DOC
    ../../Doc/: readme.txt
